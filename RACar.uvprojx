# Keil uVision project RACar.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RACar
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TRK_KEA128,CPU_KEA128,IAR
  c include: .\common;.\cpu;.\drivers;.\Peripherals;.\RAbuild\inc;.\RTE\Device\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group drivers
    ./drivers/: adc.c ftm.c gpio.c pit.c systick.c uart.c
  group Peripherals
    ./Peripherals/: LQ12864.c LQKEY.c LQLED.c
  group common
    ./common/: assert.c
  group CPU
    ./cpu/: arm_cm0.c
  group CMSIS
    ./cpu/: system_SKEAZ1284.c
    ./RTE/Device/SKEAZ128xxx4/: startup_SKEAZ1284.s
  group RAbuild
    ./RAbuild/: System.c deal.c getsig.c Motor.c Readme.md
    ./Peripherals/: isr.c main.c
